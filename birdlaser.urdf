Commit message: Did you know? burb

File: birdlaser.urdf (robot description, URDF)
Before this commit: robot birdlaser, 8 links, 7 joints
Joints:
- joint base_link_to_board: origin rpy=-1.57079632679 0 3.14159265359 -> xyz=-.116525 -.06525 -.03 rpy=-1.57079632679 0 3.14159265359
